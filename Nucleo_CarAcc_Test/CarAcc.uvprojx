# Keil uVision project CarAcc.uvprojx, settings and files
target STM32F767ZI-Nucleo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CarAcc +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_STM32F7XX_NUCLEO_144
  c misc: --C99
  c include: D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Device\ST\STM32F7xx\Include;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\CMSIS\Include;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\STM32F7xx_HAL_Driver\Inc;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\BSP\STM32F7xx_Nucleo_144;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Drivers\BSP\Components\Common;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Utilities\Log;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Utilities\Fonts;D:\DevelopProgramFiles\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.9.0\Utilities\CPU;.\Inc;..\Nucleo_SD_Test\Inc;..\SPILibForSensor
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Inc
    ./Inc/: main.h stm32f7xx_hal_conf.h stm32f7xx_it.h
    ../Nucleo_SD_Test/Inc/: looke_fileFormat_SD.h
    ../SPILibForSensor/: MPU9250.h
  group MDK-ARM
    ./MDK-ARM/: startup_stm32f767xx.s
  group Src
    ./Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
    ../Nucleo_SD_Test/Src/: looke_fileFormat_SD.c
  group Drivers/BSP/STM32F767ZI-Nucleo
    D:/DevelopProgramFiles/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.9.0/Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Drivers/STM32F7xx_HAL_Driver
    D:/DevelopProgramFiles/Keil_v5/ARM/PACK/Keil/STM32F7xx_DFP/2.9.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sd.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_exti.c
  group Drivers/CMSIS
    ./Src/: system_stm32f7xx.c
software components: CMSIS:CORE 5.0.2
